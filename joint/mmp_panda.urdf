Commit message: UI working for joints example

File: joint/mmp_panda.urdf (robot description, URDF)
Before this commit: robot mmp_panda, 14 links, 13 joints
Links:
- link base_theta: geometry visual mesh filename=../../../model/mmp_panda_tall/meshes/panda_TallBaseCombo.obj
